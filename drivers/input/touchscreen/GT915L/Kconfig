## drivers/input/touchscreen/GT915L/Kconfig
```kconfig
config TOUCHSCREEN_GT915L
	bool "Goodix GT915L touchpanel driver"
	depends on CONFIG_INPUT_TOUCHSCREEN
	default n
```
